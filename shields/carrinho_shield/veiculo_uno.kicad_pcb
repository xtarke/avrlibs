# Repository xtarke/avrlibs

File README.md:

# AVR libs: exemplos para Microcontroladores AVR

Notas, exemplos e bibliotecas para a disciplina de Microntroladores do Instituto Ferderal de Santa Catarina

## Getting Started

Clone o repositório e adicione os arquivos no seu projeto. Evite compilar mais de uma função main.

## KiCad design shields/carrinho_shield/veiculo_uno.kicad_pcb

File shields/carrinho_shield/README.md:

# Interface shield

This shield connects Arduino Uno pins to the car's power board. Go to [Power Board](https://github.com/xtarke/avrlibs/tree/master/shields/carrinho_potencia) for more hardware information.

See [this schematic](schematic.pdf).

## Analog pins

| Analog input  | Arduino pin  | Board label  | Signal |
| ------------- | -------- | ------------ | ------ |
| ADC0          | A2       |   ADC0       | Bat0   |
| ADC1          | A1       |   ADC1       | Bat1   |
| ADC2          | A0       |   ADC2       | Ampop1 |
| ADC3          | A3       |   ADC3       | Ampop2 |

## Ultrasonic sensor

| Arduino Pin | Signal|
| ------- | ------|
| 8       | Echo0 |
| 7       | Trig0 |
| 2       | Echo1 |
| 4       | Trig1 |

## Motors

|Arduino Pin | Signal|  Board label |
| ---------- | ------| ------------ |
| 6          | PWM1  |  M1          |
| 5          | PWM1N |  M1N         |
| 11         | PWM2  |  M2          |
| 3          | PWM2N |  M2N         |

## Espeed econder

| Arduino Pin | Signal |  Board label |
| ----------- | ------ | ------------ |
| 13          | D0     | ENC0         |
| 12          | D1     | ENC1         |

## Optic sensor

| Arduino Pin | Signal | Board label |
| ----------- | ------ | ----------- |
| A4          | R_TCRT | R DIR       |
| A5          | L_TCRT | L ESQ       |

## UART

| MSP Pin | Signal |
| ------- | ------ |
| TX      | TX     |
| RX      | RX     |

Parts:
C1, C2: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: LED; LED_0805_2012Metric
D2: D_Schottky; D_SMB
J1, J2, J3, J4, J5, J6, J8, J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J7: Conn_02x13_Odd_Even; PinSocket_2x13_P2.54mm_Vertical
J23: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
P1: Power; Socket_Strip_Arduino_1x08
P2: Analog; Socket_Strip_Arduino_1x06
P3: Digital; Socket_Strip_Arduino_1x10
P4: Digital; Socket_Strip_Arduino_1x08
P6, P7, P8: CONN_01X01; Arduino_1pin
Q1, Q2: 2N7002; SOT-23
R1: R; R_0805_2012Metric
R2, R3, R4, R5: 2k2; R_0805_2012Metric

Connections:
2: J10.2, P4.6
3: J15.2, P4.5
4: J13.2, P4.4
5: J20.2, P4.3
6: J21.2, P4.2
7: J12.2, P4.1
8: J11.2, P3.10
9: P3.9
10: P3.8
11: J19.2, P3.7
12: J16.2, P3.6
13: J14.2, P3.5
+3V3: C2.1, J23.2, P1.4, Q1.1 (G), Q2.1 (G), R2.1, R4.1
+5V: C1.1, D1.2 (A), D2.1, J23.1, J23.3, P1.5, R3.1, R5.1
+5VP: D2.2, J7.15, J7.16
/AREF: P3.3
/IOREF: P1.2
/Reset: P1.3
/Vin: P1.8
A0: J3.2, P2.1
A1: J2.2, P2.2
A2: J1.2, P2.3
A3: J4.2, P2.4
A4(SDA): J8.2, P2.5, P3.2
A5(SCL): J9.2, P2.6, P3.1
ADC0: J1.1, J7.7
ADC1: J2.1, J7.9
ADC2: J3.1, J7.11
ADC3: J4.1, J7.5
AMP1: J5.2, J7.3
AMP2: J6.2, J7.13
D0: J7.2, J14.1
D1: J7.24, J16.1
Echo0: J7.22, J11.1
Echo1: J7.6, J10.1
GND: C1.2, C2.2, J5.1, J6.1, J7.1, J7.4, J7.18, J23.4, P1.6, P1.7, P3.4, R1.2
L_TCRT: J7.14, J9.1
unnamed: D1.1 (K), R1.1
unnamed: J17.2, Q1.2 (S), R2.2
unnamed: J18.2, Q2.2 (S), R4.2
PWM1: J7.21, J21.1
PWM1N: J7.23, J20.1
PWM2: J7.25, J19.1
PWM2N: J7.26, J15.1
RXB: J7.19, J17.1
R_TCRT: J7.12, J8.1
Rx: P4.8, Q2.3 (D), R5.2
TXB: J7.17, J18.1
Trig0: J7.20, J12.1
Trig1: J7.8, J13.1
Tx: P4.7, Q1.3 (D), R3.2

Notes on the sheet:
Holes
Shield for Arduino that uses the same pin disposition like "Uno" board Rev 3.
11 - OC2A 3 - OC2B 6 - OC0A 5- OC0B
2 - int0 (ext. event) 8 - ICP1 (capture) 4 - GPIO 7 - GPIO
Encoder
Sensor optico
SHIELD ARDUINO PARA CARRINHO AUTÔNOMO LIGAÇÃO CONFORME PLACA DE POTÊNCIA
Módulo Bluetooth HC05 I/O em 3V3

Board: 2 copper layers, 68.6 x 53.3 mm, 40 parts (9 on the bottom side), 45 nets.

## KiCad design shields/carrinho/Hardware.kicad_pcb

Parts:
C1, C2: 1n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C4: 100n; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8: DIODE; D_A-405_P2.54mm_Vertical_KathodeUp
D9, D10, D11: LED; LED_0805_2012Metric
D12: D_Schottky; D_SMB
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3
J1, J3, J13, J14: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J2, J10, J11: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J4, J5, J6, J7: Conn_01x02_Male; PinSocket_1x02_P2.54mm_Vertical
J8, J9: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J12: Conn_02x13_Odd_Even; PinSocket_2x13_P2.54mm_Vertical
Q1, Q2, Q7, Q8: BD140; TO-126-3_Vertical
Q3, Q4, Q9, Q10: BC548; TO-92_Inline_Wide
Q5, Q6, Q11, Q12: BD139; TO-126-3_Vertical
R1, R2, R5, R6: 470; R_0805_2012Metric
R3, R4, R7, R8: 150; R_0805_2012Metric
R9, R10, R15, R16, R26, R28: 10k; R_0805_2012Metric
R11, R13: 30k; R_0805_2012Metric
R12, R14: 15k; R_0805_2012Metric
R17, R18, R19, R20, R21, R22, R23, R24: R; R_0805_2012Metric
R25, R27: 1k; R_0805_2012Metric
R29, R30, R35: 1K; R_0805_2012Metric
R31, R32, R33, R34: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV1, RV2: R_POT_TRIM; Potentiometer_Piher_PT-6-V_Vertical
U1: LM393
U2, U5: TCRT5000; OPTO_TCRT5000
U3: LM324
U4: HC-05; PinHeader_1x06_P2.54mm_Horizontal

Connections:
+5V: C3.1, C4.1, D11.2 (A), J7.1, J7.2, J8.1, J9.1, J10.1, J11.1, J12.15, J12.16, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R33.1, R34.1, RV1.1, RV2.1, U1.8 (V+), U3.4 (V+), U4.5
A1: J12.3, R21.2
A2: J12.13, R22.2
ADC0: J12.7, R9.1, U3.14
ADC1: J12.9, R10.1, U3.1
ADC2: J12.11, R18.1, U3.7
ADC3: J12.5, R17.1, U3.8
BATMed: J2.2, J2.3, R14.2
D0: C2.1, J12.2, R32.2
D1: C1.1, J12.24, R31.2
Echo0: J10.3, J12.22
Echo1: J11.3, J12.6
GND: C1.2, C2.2, C3.2, C4.2, D3.1 (K), D4.1 (K), D7.1 (K), D8.1 (K), J2.4, J4.1, J4.2, J5.1, J5.2, J8.2, J9.2, J10.4, J11.4, J12.1, J12.4, Q5.1 (E), Q6.1 (E), Q11.1 (E), Q12.1 (E), R11.2, R12.2, R15.2, R16.2, R19.2, R20.2, R23.2, R24.2, R35.2, RV1.3, RV2.3, U1.4 (V-), U2.CATH, U2.E, U3.11 (V-), U4.4, U5.CATH, U5.E
L_TCRT: D10.1 (K), J12.14, R34.2, U1.7
unnamed: D1.1 (K), D3.2 (A), J1.1, J3.1, Q1.2 (C), Q5.2 (C)
unnamed: D2.1 (K), D4.2 (A), J1.2, J3.2, Q2.2 (C), Q6.2 (C)
unnamed: D5.1 (K), D7.2 (A), J13.1, J14.1, Q7.2 (C), Q11.2 (C)
unnamed: D6.1 (K), D8.2 (A), J13.2, J14.2, Q8.2 (C), Q12.2 (C)
unnamed: D9.2 (A), R29.2
unnamed: D10.2 (A), R30.2
unnamed: D11.1 (K), R35.1
unnamed: J8.3, R31.1
unnamed: J9.3, R32.1
unnamed: Q1.3 (B), Q3.1 (C)
unnamed: Q2.3 (B), Q4.1 (C)
unnamed: Q3.2 (B), R1.1
unnamed: Q3.3 (E), R3.2
unnamed: Q4.2 (B), R2.2
unnamed: Q4.3 (E), R4.1
unnamed: Q5.3 (B), R4.2
unnamed: Q6.3 (B), R3.1
unnamed: Q7.3 (B), Q9.1 (C)
unnamed: Q9.2 (B), R5.1
unnamed: Q9.3 (E), R7.2
unnamed: Q8.3 (B), Q10.1 (C)
unnamed: Q10.2 (B), R6.2
unnamed: Q10.3 (E), R8.1
unnamed: Q11.3 (B), R8.2
unnamed: Q12.3 (B), R7.1
unnamed: R10.2, R12.1, U3.2 (-)
unnamed: R9.2, R11.1, U3.13 (-)
unnamed: R13.1, R15.1, U3.12 (+)
unnamed: R14.1, R16.1, U3.3 (+)
unnamed: R17.2, R19.1, U3.9 (-)
unnamed: R18.2, R20.1, U3.6 (-)
unnamed: R21.1, R23.1, U3.10 (+)
unnamed: R22.1, R24.1, U3.5 (+)
unnamed: R25.2, U2.A
unnamed: R26.2, U1.3 (+), U2.COLL
unnamed: R27.2, U5.A
unnamed: R28.2, U1.5 (+), U5.COLL
unnamed: RV1.2, U1.2 (-)
unnamed: RV2.2, U1.6 (_)
PWM1: J12.21, R2.1
PWM1N: J12.23, R1.2
PWM2: J12.25, R6.1
PWM2N: J12.26, R5.2
RXB: J12.19, U4.2
R_TCRT: D9.1 (K), J12.12, R33.2, U1.1
TXB: J12.17, U4.3
Trig0: J10.2, J12.20
Trig1: J11.2, J12.8

Notes on the sheet:
Carro bluetooth hardware
09/05/2019
2.0
IFSC
Projeto integrador III
Lucas Odair Silva
Engenharia Eletrônica
Ponte H Lado direito
Ponte H Lado esquerdo
Diferencial bateria
Modulo bluetooth
Conector da bateria
Regulador de tensão
Controll conector
Encoder velocidade
Diferencial
HC-SR04
TCRT5000

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
Board: 2 copper layers, 135.7 x 56.1 mm, 87 parts (46 on the bottom side), 64 nets.

## KiCad design shields/cnc/cnc.kicad_pcb

File shields/cnc/README.md:

# Rolland PNC-2300

Adaptação eletrônica da Rolland PNC-2300.

Novas funções:
  - Fim de curso nos eixos x,y e z.
  - Auto nivelamento.

## Conexões:

- Enable (inverted):

    - ENA- : GND
    - ENA+ : Arduino GPIO  (driver in Figure)

- Direction:

    - DIR- : Arduino GPIO (driver in Figure)
    - DIR+ : +5V

- Pulses:

    - PUL- : Arduino GPIO (driver in Figure)
    - PUL+ : +5V

 - Switches: Habilitado debounce por software em config.h (GRBL).
             Colocado capacitor 22nF no eixo Z

 - Fundo de escala eixo Z: 26.65mm (depende da ferramenta)

 - Auto nivelamento:
    - Probe Pin (Arduino A5): https://github.com/grbl/grbl/wiki/Connecting-Grbl

## Software CNC

- Arduino Uno: [grbl](https://github.com/grbl/grbl)

```
$0 = 10    (step pulse, usec)
$1 = 25    (step idle delay, msec)
$2 = 0    (step port invert mask:00000000)
$3 = 1    (dir port invert mask:00000001)
$4 = 0    (step enable invert, bool)
$5 = 0    (limit pins invert, bool)
$6 = 0    (probe pin invert, bool)
$10 = 31    (status report mask:00011111)
$11 = 0.010    (junction deviation, mm)
$12 = 0.002    (arc tolerance, mm)
$13 = 0    (report inches, bool)
$20 = 0    (soft limits, bool)
$21 = 1    (hard limits, bool)
$22 = 1    (homing cycle, bool)
$23 = 3    (homing dir invert mask:00000011)
$24 = 200.000    (homing feed, mm/min)
$25 = 500.000    (homing seek, mm/min)
$26 = 250    (homing debounce, msec)
$27 = 1.000    (homing pull-off, mm)
$100 = 290.000    (x, step/mm)
$101 = 290.000    (y, step/mm)
$102 = 3209.000    (z, step/mm)
$110 = 500.000    (x max rate, mm/min)
$111 = 500.000    (y max rate, mm/min)
$112 = 500.000    (z max rate, mm/min)
$120 = 10.000    (x accel, mm/sec^2)
$121 = 10.000    (y accel, mm/sec^2)
$122 = 10.000    (z accel, mm/sec^2)
$130 = 200.000    (x max travel, mm)
$131 = 200.000    (y max travel, mm)
$132 = 200.000    (z max travel, mm)
```

## Software G-code

- bCNC:
  - Envio de G-codes.
  - Auto-nivelamento.
  - [bCNC Github](https://github.com/vlachoudis/bCNC)
  - [Vídeo](https://www.youtube.com/watch?v=icJ4m5zBqoA)

- Criação do G-code à partir do gerber.
  - [Flatcam](http://flatcam.org/)
  - [Vídeo](https://www.youtube.com/watch?v=O3GZsEHeH8w)

- Testes rápidos:
  - [Universal Gcode Sender](http://winder.github.io/ugs_website/download/) (use Feed rate = 200)

## Regras PCBs

| Parâmetro  |             |
|------------|-------------|
| Clearance  | 12mils      |
| Track W    | 20 a 30mils |
| Via Dia    | 1.8mm       |
| Via Drill  | 0.6mm       |
| uVia Drill | 1.8mm       |
| uVia Drill | 0.6mm       |

- Cuidado com conectores. Sugere-se aumentar a área dos pads com furo de 1mm para 2x2mm para aumentar a área de cobre pós furo. __Para alterar todos: Clique direito, pads, Push pad proprieties__

- Faça os furos de alinhamento no centro do eixo X e nos limites da placa para placas dupla-face:

## Geração de g-code pelo Flatam

1. Carregar o gerber bottom:

2. Carregar p gerber drill.

3. Fazer o espelhamento (Tools - Doubled-side PCB tool)
  - __Certifique-se que o espelhamento do Flatcam esteja de acordo com o diagrama 3D.__

3. Alinhar os furos de aliamento na coordenada (0,0) após o espelhamento.
  - Para alinhar o drill, use o vetor (-0.3, -0.3)
  - Para alinhar o bottom, use o vetor (-0.75, -0.75)
  - __Valores do vetor baseaiam-se em uma uma via: furo de 0.6mm e pad de 1.5mm após o Offset Auto.__

4. Gerar o G-Code com o seguintes parâmetros (Generate Geometry):

| Parâmetro     |       |
|---------------|-------------|
| Z Cut         | -0.1        |
| Tool diameter | 0.3 (varia com a ferramenta)       |
| Overlap       | 0.0001      |
| Feed rate     | 150         |
| Travel Z      | 1           |

5. Gerar o g-code para marcação dos furos.
  - Selecione o gerber drill.

  | Parâmetro     |       |
  |---------------|-------------|
  | Z Cut         | -0.1        |
  | Feed rate     | 150         |
  | Travel Z      | 1           |

## Usando o bCNC para usinar a placa

ToDO....

## Refs:

- Hardware: https://blog.protoneer.co.nz/wp-content/uploads/2013/07/Arduino-CNC-Shield-Schematics.png

Board: 2 copper layers, 73.0 x 110.5 mm, 46 parts (0 on the bottom side), 30 nets.

Parts:
D1, D2: DIODE; D_DO-201_P15.24mm_Horizontal
HS1, HS2: Heatsink; Heatsink_Fischer_SK104-STC-STIC_35x13mm_2xDrill2.5mm
J1, J2, J3, J4, J5, J6, J8, J9, J10, J12, J19, J24: Conn_01x02_Male; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J7, J11, J23: Conn_01x02_Male; TerminalBlock_bornier-2_P5.08mm
J13, J14, J15, J16, J17, J18, J20, J21, J22: Conn_01x03_Male; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
P1: Power; Socket_Strip_Arduino_1x08
P2: Analog; Socket_Strip_Arduino_1x06
P3: Digital; Socket_Strip_Arduino_1x10
P4: Digital; Socket_Strip_Arduino_1x08
P5, P6, P7, P8: CONN_01X01; Arduino_1pin
Q1, Q2: IRF540N; TO-220-3_Vertical
R1, R2, R3, R4, R5, R6: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1, U2: 4N25; DIP-6_W7.62mm

Connections:
+5V: J13.1, J14.1, J15.1, J16.1, J17.1, J18.1, J20.1, J21.1, J22.1, P1.5
+24V: D1.2, D2.2, J7.1, J11.1, J23.1, U1.5, U2.5
CONTROL_CYCLE_START: J19.1, P2.3
CONTROL_RESET: J12.1, P2.1
CONTROL_SAFETY_DOOR: J24.1, P2.2
Coolant: P2.4, R4.2
Dir-X: J13.2, P4.3
Dir-Y: J17.2, P4.2
Dir-Z: J21.2, P4.1
E-Stop: J5.1, P1.3
Enable: J15.2, J16.2, J20.2, P3.10
GND: J1.2, J2.2, J3.2, J5.2, J6.2, J8.2, J9.2, J10.2, J12.2, J13.3, J14.3, J15.3, J16.3, J17.3, J18.3, J19.2, J20.3, J21.3, J22.3, J24.2, P1.6, P1.7, P3.4, U1.2, U2.2
GNDPWR: J7.2, Q1.3, Q2.3, R3.2, R6.2
unnamed: D1.1, J11.2, Q1.2
unnamed: D2.1, J23.2, Q2.2
unnamed: J4.1, R1.2
unnamed: Q1.1, R2.1, R3.1
unnamed: Q2.1, R5.1, R6.1
unnamed: R1.1, U1.1
unnamed: R2.2, U1.4
unnamed: R4.1, U2.1
unnamed: R5.2, U2.4
SpinDir: J6.1, P3.5
SpinEnable: J4.2, P3.6
Step-X: J14.2, P4.6
Step-Y: J18.2, P4.5
Step-Z: J22.2, P4.4
X-EndStop: J1.1, J8.1, P3.9
Y-EndStop: J2.1, J9.1, P3.8
Z-EndStop: J3.1, J10.1, P3.7

## KiCad design shields/esp-01/shield.kicad_pcb

Parts:
C1: 2.2u; C_1206
D1: LED; LED-5MM
JP1, JP2, JP3, JP4: Jumper; Pin_Header_Straight_1x02
P1: Power; Socket_Strip_Arduino_1x08
P2: Analog; Socket_Strip_Arduino_1x06
P3: Digital; Socket_Strip_Arduino_1x10
P4: Digital; Socket_Strip_Arduino_1x08
P5, P6, P7, P8: CONN_01X01; Arduino_1pin
Q1, Q2: 2N7002; SOT-23
R1, R2, R3, R4, R5, R6: 2K2; R_0805
SW1: SW_Push_Dual; SW_TH_Tactile_Omron_B3F-10xx
U1: ESP-01v090; ESP-01

Connections:
+3V3: C1.1, P1.4, Q1.1 (G), Q2.1 (G), R1.1, R2.1, R3.1, U1.7 (VCC)
+5V: P1.5, R4.1, R5.1
/2: P4.6
/3(**): P4.5
/4: P4.4
/5(**): P4.3
/6(**): P4.2
/7: P4.1
/8: P3.10
/9(**): P3.9
/10(**/SS): P3.8
/11(**/MOSI): P3.7
/12(MISO): P3.6
/13(SCK): P3.5
/A0: P2.1
/A1: P2.2
/A2: P2.3
/A3: P2.4
/A4(SDA): P2.5, P3.2
/A5(SCL): P2.6, P3.1
/AREF: P3.3
/IOREF: P1.2
/Vin: P1.8
ARD_RST: JP4.1, P1.3
FIW: JP3.1, U1.6 (GPIO0)
GND: C1.2, D1.1 (K), JP3.2, JP4.2, P1.6, P1.7, P3.4, SW1.2, SW1.4, U1.2 (GND)
unnamed: D1.2 (A), R6.1
unnamed: JP1.1, Q1.3 (D), R4.2
unnamed: JP2.1, Q2.3 (D), R5.2
unnamed: R1.2, U1.3 (CH_PD)
unnamed: R6.2, U1.4 (GPIO2)
RST: SW1.1, SW1.3, U1.5 (RST)
RX: JP2.2, P4.8
RX_l: Q2.2 (S), R3.2, U1.1 (UTXD)
TX: JP1.2, P4.7
TX_l: Q1.2 (S), R2.2, U1.8 (URXD)

Notes on the sheet:
Holes
Shield for Arduino that uses the same pin disposition like "Uno" board Rev 3.

Board: 2 copper layers, 68.6 x 53.3 mm, 24 parts (9 on the bottom side), 17 nets.

## Commit log

2018-04-18 Added public files
2018-04-24 Added adc config registers
2018-05-01 Added usart lib
2018-05-22 Added spi module
2018-05-30 Added i2c master files
2018-06-08 Added fsm and complex functions
2018-06-13 Added main_sin
2018-06-22 Corrected some macros
2018-08-02 Added asm examples
2018-08-16 New gpio lib
2018-08-20 Added led display example
2018-08-24 Corrected gpio.h
2018-08-24 y buggy
2018-08-27 Added display libraries
2018-08-27 Added makefile simple example
2018-08-28 Added lcd main example
2018-08-31 Added usart debug examples
2018-09-03 added external irq example
2018-09-11 Correct macro in ext irq
2018-09-24 Added timer example
2018-09-24 Check speling
2018-10-01 Added PWM example
2018-10-04 Added analog comp. example
2018-10-08 Added adc example
2018-10-16 Added fsm example
2018-10-22 Added sin table
2018-10-25 Added ntc ods file
2018-11-22 Added spi example
2018-11-26 Added lcd i2c example
2018-11-27 Added lcd_i2c
2018-12-04 Added modbus example
2019-04-30 Added ADC with timer0 trigger
2019-06-04 Added DS1307 i2c example
2019-06-04 Corrected indentation
2019-06-18 Added esp-01 shield
2019-08-09 Added exercices
2019-08-09 Added asm files
2019-08-16 Added i/o macro
2019-08-26 Correct display MUX
2019-09-08 Added hardware to shields
2019-09-17 Improved schematic
2019-09-18 Revised schemeatic
2019-09-18 Changed motors conector, added capacitor near ampop
2019-09-19 Changed pots
2019-09-20 Added auto car test
2019-09-27 Updated car PCB
2019-10-04 Updaded board
2019-10-15 Updaded pdf
2019-10-18 Added new app file
2019-10-18 Teste left and right
2019-10-18 Testing auto test
2019-10-18 Tested motors with HC-05.
2019-10-25 Added low power example.
2019-10-31 Add uart exemple
2019-11-01 Revisado esquematico
2019-11-07 Adicionado exmplos com IRQ da USART.
2019-11-07 Adicionado guarda na IRQ.
2020-02-26 Added CNC shield
2020-02-27 Added readme
2020-03-03 placa pronta
2020-04-28 Added pdf project file
2020-06-08 Added shield files
2020-06-08 Added shield schematic
2020-06-09 Done PCI layout
2020-06-25 Added shield documentation
2020-06-25 Added 3d model
2020-06-25 Added more images
2020-07-06 Added docs
2020-07-06 Removed backup files
2020-08-19 Updated readme with figures
2020-08-25 Update README.md
    Tested home cycle and hard limit switches.
2020-09-18 Added level converter RX / TX signals
2020-10-06 Added aligment holes
2020-10-08 Added manual
2020-10-22 Added diode in +5V.
2020-11-27 Added readme. Robotic arm config
2020-12-15 Change 26 pins connector
2021-03-09 Added PCB labels
